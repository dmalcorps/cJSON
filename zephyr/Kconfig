## zephyr/Kconfig
```kconfig
config CJSON_LIB
	  bool "Enable cjson"
	  help
	    This option enables cjson as a Zephyr module.
```
